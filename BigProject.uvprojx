# Keil uVision project BigProject.uvprojx, settings and files
target F103ZE (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BigProject +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\USER\EXTRA\dev_hzy;.\USER\EXTRA\dev_dyw;.\USER\EXTRA\dev_xyj;.\USER;.\USER\EXTRA;.\LIB\inc;.\CORE;.\USER\EXTRA\delay;.\USER\EXTRA\sys;.\USER\EXTRA\usart;.\USER\EXTRA\RTC;.\USER\EXTRA\LED;.\USER\EXTRA\KEY;.\USER\EXTRA\LCD;.\USER\EXTRA\FATFS\src;.\USER\EXTRA\FATFS\exfuns;.\USER\EXTRA\MALLOC;.\USER\EXTRA\PICTURE;.\USER\EXTRA\SDIO;.\USER\EXTRA\SPI;.\USER\EXTRA\TEXT;.\USER\EXTRA\W25QXX
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group USER_EXTRA
    ./USER/EXTRA/delay/: delay.c
    ./USER/EXTRA/sys/: sys.c
    ./USER/EXTRA/usart/: usart.c
    ./USER/EXTRA/RTC/: rtc.c
    ./USER/EXTRA/LCD/: lcd.c
    ./USER/EXTRA/SPI/: spi.c
    ./USER/EXTRA/W25QXX/: w25qxx.c
    ./USER/EXTRA/SDIO/: sdio_sdcard.c
  group LIB
    ./LIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CORE
    ./CORE/: core_cm3.c startup_stm32f10x_hd.s
  group MALLOC
    ./USER/EXTRA/MALLOC/: malloc.c
  group FATFS
    ./USER/EXTRA/FATFS/src/: diskio.c ff.c
    ./USER/EXTRA/FATFS/exfuns/: exfuns.c fattester.c mycc936.c
  group TEXT
    ./USER/EXTRA/TEXT/: fontupd.c text.c
  group PICTURE
    ./USER/EXTRA/PICTURE/: bmp.c gif.c piclib.c tjpgd.c
  group DOC
    ./DOC/: README.md
  group USER_EXTRA/hzy
    ./USER/EXTRA/dev_hzy/: key.c
  group USER_EXTRA/xyj
    ./USER/EXTRA/dev_xyj/: led.c
  group USER_EXTRA/dyw
    ./USER/EXTRA/dev_dyw/: lcd_display.c main_interface.c
